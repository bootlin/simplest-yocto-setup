SRC_URI:append:freiheit93 = " file://0001-arm64-dts-add-i.MX93-11x11-FRDM-basic-support.patch"
