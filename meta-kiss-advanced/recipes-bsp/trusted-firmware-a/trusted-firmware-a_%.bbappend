COMPATIBLE_MACHINE:freiheit93 = "^freiheit93$"
