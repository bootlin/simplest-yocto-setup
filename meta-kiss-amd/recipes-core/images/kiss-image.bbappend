IMAGE_INSTALL:append:zynqmp = " fpga-bitstream"
