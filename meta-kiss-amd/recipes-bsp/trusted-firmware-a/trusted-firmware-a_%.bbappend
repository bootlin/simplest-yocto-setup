COMPATIBLE_MACHINE:zynqmp = "^zynqmp$"
